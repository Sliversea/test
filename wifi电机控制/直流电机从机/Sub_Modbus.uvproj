# Keil uVision project Sub_Modbus.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A16S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: Sub_Modbus +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: ACD.c ADC.c ADXL345.c AM2321.c CC1101.c crc.c main.c STC12C5A60S2_EEPROM.c GF3658.c SHT10.c
